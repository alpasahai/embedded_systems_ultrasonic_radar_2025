# Keil uVision project ultrasonic_radar.uvprojx, settings and files
target Target 1 (6240000::V6.24::ARMCLANG)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ultrasonic_radar
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source Group 1
    ./: main.c servo_motor_functions.c servo_motor_functions.h ranger_functions.h ranger_functions.c ES.h LCD_Display.h lcd_functions.c lcd_functions.h buzzer_functions.c buzzer_functions.h joystick_functions.c joystick_functions.h
    ./Objects/: ES.lib LCD_Display.lib
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.0
